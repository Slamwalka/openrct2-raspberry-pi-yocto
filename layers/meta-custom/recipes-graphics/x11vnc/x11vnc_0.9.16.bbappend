FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://0001-x11vnc-add-independent-pointer-rotation.patch"
