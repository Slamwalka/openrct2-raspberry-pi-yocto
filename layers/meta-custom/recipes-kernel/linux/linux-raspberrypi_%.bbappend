FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://rpi-openrct2-touch-display.cfg"